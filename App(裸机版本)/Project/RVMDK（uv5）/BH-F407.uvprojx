# Keil uVision project BH-F407.uvprojx, settings and files
target App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\EMWin\Config;..\..\EMWin\inc;..\..\EMWinApp;..\..\User\usart;..\..\User\tim;..\..\User\led;..\..\User\lcd;..\..\User\key;..\..\User\font;..\..\User\can;..\..\User\sdio;..\..\XCPDriver;..\..\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c stm32f4xx_conf.h
    ../../User/sdio/: sd.c bsp_sdio_sd.c
    ../../User/font/: fonts.c
    ../../User/led/: bsp_led.c
    ../../User/key/: bsp_key.c
    ../../User/can/: bsp_can.c
    ../../User/tim/: bsp_basic_tim.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/usart/: bsp_debug_usart.c
  group FATFS
    ../../FATFS/: diskio.c ff.c
    ../../FATFS/option/: cc936.c
  group EMWin
    ../../EMWin/Config/: GUI_X.c GUIConf.c LCDConf_FlexColor_Template.c
    ../../EMWin/Lib/: STemWin532_CM4_Keil.lib
  group EMWinApp
    ../../EMWinApp/: START.c Voltage.c
  group XCPDriver
    ../../XCPDriver/: xcp_par.c xcp_appl.c XcpBasic.c
  group DOC
    ../../: readme.txt
