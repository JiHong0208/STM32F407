# Keil uVision project App_FreeRTOS.uvprojx, settings and files
target App_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,OS_SUPPORT
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\STemWin\Config;..\..\STemWin\inc;..\..\STemWin_Task;..\..\XCPDriver;..\..\FATFS;..\..\User;..\..\User\adc;..\..\User\can;..\..\User\flash;..\..\User\font;..\..\User\key;..\..\User\lcd;..\..\User\led;..\..\User\sdio;..\..\User\sram;..\..\User\systick;..\..\User\usart;..\..\User\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
    ../../User/sdio/: sd.c bsp_sdio_sd.c
    ../../User/led/: bsp_led.c
    ../../User/key/: bsp_key.c
    ../../User/can/: bsp_can.c
    ../../User/rtc/: bsp_rtc.c
    ../../User/sram/: bsp_sram.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/usart/: bsp_debug_usart.c
  group STemWIN/Task
    ../../STemWin_Task/: GraphDLG.c START.c
  group STemWIN
    ../../STemWin/Config/: GUIConf.c GUIConf.h LCDConf_FlexColor.c
    ../../STemWin/OS/: GUI_X_FreeRTOS.c
    ../../STemWin/Lib/: STemWin_CM4_OS_wc16_ot_ARGB.a
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group XCPDriver
    ../../XCPDriver/: xcp_appl.c xcp_par.c XcpBasic.c
  group FATFS
    ../../FATFS/option/: cc936.c
    ../../FATFS/: diskio.c ff.c
  group DOC
    ../../: 必读说明.txt
